v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
C {home/abishek/SRAM_WORK/osu-toy-sram/custom_layout/10T_1x32_xschem.sym} 120 30 0 0 {name=x1 VDD=VDD GND=GND}
